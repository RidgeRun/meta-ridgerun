PACKAGECONFIG_append = " x264 gpl"
