DEPENDS += "gstcameradrivermeta"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-Propagate-cameradrivermeta.patch"