require gst-shark.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=e1caa368743492879002ad032445fa97"