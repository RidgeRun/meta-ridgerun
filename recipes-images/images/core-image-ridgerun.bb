DESCRIPTION = "Base image with RidgeRun custom configuration"

LICENSE = "MIT"

inherit core-image

IMAGE_INSTALL += "<PACKAGES>"
