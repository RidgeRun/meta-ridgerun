FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-cuda-translate-external-ldflags-for-nvcc.patch"
