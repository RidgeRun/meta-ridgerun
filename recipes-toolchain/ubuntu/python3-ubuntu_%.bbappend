SRC_URI:remove:ubuntu = "http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/python3.8/libpython3.8-testsuite_3.8.10-0ubuntu1~20.04.12_all.deb;name=libpython3.8-testsuite"
SRC_URI:append:ubuntu = " http://launchpadlibrarian.net/748687682/libpython3.8-testsuite_3.8.10-0ubuntu1~20.04.12_all.deb;name=libpython3.8-testsuite"
SRC_URI:remove:ubuntu = "http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/python3.8/python3.8-full_3.8.10-0ubuntu1~20.04.12_arm64.deb;name=python3.8-full"
SRC_URI:append:ubuntu = " https://code.launchpad.net/~ubuntu-security-proposed/+archive/ubuntu/ppa/+build/28936221/+files/python3.8-full_3.8.10-0ubuntu1~20.04.12_arm64.deb;name=python3.8-full"
