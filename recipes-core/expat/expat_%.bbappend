EXTRA_OECONF += "--without-docbook"
